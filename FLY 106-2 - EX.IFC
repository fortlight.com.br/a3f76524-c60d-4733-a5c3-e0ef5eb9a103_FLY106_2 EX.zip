Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: I:\A - PROJETO NOVO WORKSPACE\ENGENHARIA LUMINARIA\A - PROJETOS & DESENVOLVIMENTO\FLY 1__-2\EM ANDAMENTO\DESENHOS\MONTAGEM\FLY 106_2 - ARANDELA 90°\PARA ENVIO\FLY 106-2 - EX.IFC
Time: 2024-11-06T14:34:00+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
